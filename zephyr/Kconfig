## zephyr/Kconfig
```kconfig
menuconfig CFL
    bool "Custom messaging protocol support"
    help
    Enable control freak lite support
```
